Commit message: Add files via upload

File: roboto.urdf (robot description, URDF)
Before this commit: robot roboto, 6 links, 4 joints
Links:
- removed link right_wheel_turn
